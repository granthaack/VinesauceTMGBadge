# Repository granthaack/VinesauceTMGBadge

## EAGLE design vine_badge.brd

Parts:
C1: 100nF; C0603
C2: 10uF; C/6032-28R
D1: DIODE-SOD523; SOD523
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
FUSE: 1206_FUSE; R1206
JP1: PINHD-1X3; 1X03
JP2: JUMPER-SMT_2_NC_TRACE_NO-SILK; SMT-JUMPER_2_NC_TRACE_NO-SILK
JP3: JUMPER-SMT_2_NO_NO-SILK; SMT-JUMPER_2_NO_NO-SILK
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30: LEDCHIPLED_0603; CHIPLED_0603
LOGO1: OSHW-LOGOS-COPPER; OSHW-LOGO-S_COPPER
ON/OFF: ON/OFF; SMT_DPDT
R1, R2, R3, R4, R5, R6: R-US_R0603; R0603
R7: 1k; R0603
S2: MODE; TACTILE_SWITCH_SMD_6.0X3.5MM
U$1: ATTINY20; QFN20
U$2, U$3: AA_BATT
U$4: SI2312; SOT23

Connections:
+3V3: C1.1, C2.+, ON/OFF.P$1, ON/OFF.P$6, R7.1, U$1.9 (VCC), U$4.1 (G)
GND: C1.2, C2.-, JP3.2, S2.2, U$1.8 (GND), U$1.EXP (GND_PAD), U$4.2 (S)
MODE: S2.1, U$1.14 (PB2(CKOUT/OC0A/OC1B/MISO/INT0/PCINT10))
unnamed: LED9.C, LED10.A, LED13.C, LED14.A, LED21.C, LED22.A, LED25.C, LED26.A, LED29.C, LED30.A, R6.2
unnamed: LED1.C, LED2.A, LED3.A, LED4.C, LED11.A, LED12.C, LED17.A, LED18.C, LED25.A, LED26.C, R2.2
unnamed: LED5.C, LED6.A, LED7.A, LED8.C, LED17.C, LED18.A, LED21.A, LED22.C, LED27.C, LED28.A, R4.2
unnamed: LED3.C, LED4.A, LED5.A, LED6.C, LED13.A, LED14.C, LED15.C, LED16.A, LED19.A, LED20.C, R3.2
unnamed: LED7.C, LED8.A, LED9.A, LED10.C, LED11.C, LED12.A, LED19.C, LED20.A, LED23.C, LED24.A, R5.2
unnamed: LED1.A, LED2.C, LED15.A, LED16.C, LED23.A, LED24.C, LED27.A, LED28.C, LED29.A, LED30.C, R1.2
unnamed: U$2.P$3 (NEG1), U$2.P$4 (NEG1), U$3.P$1 (POS1), U$3.P$2 (POS1)
unnamed: R5.1, U$1.1 (PA4(PCINT4/ADC4))
unnamed: R4.1, U$1.2 (PA3(PCINT3/ADC3))
unnamed: R3.1, U$1.3 (PA2(PCINT2/AIN1/ADC2))
unnamed: R2.1, U$1.4 (PA1(PCINT1/AIN0/ADC1))
unnamed: R1.1, U$1.5 (PA0(PCINT0/ADC0))
unnamed: R6.1, U$1.17 (PA5(ADC5/PCINT5))
unnamed: FUSE.1, U$2.P$1 (POS1), U$2.P$2 (POS1)
unnamed: JP3.1, U$3.P$3 (NEG1), U$3.P$4 (NEG1), U$4.3 (D)
unnamed: D1.A, FUSE.2, JP2.1
unnamed: D1.C, JP2.2, ON/OFF.P$2, ON/OFF.P$5
RESET: JP1.1, R7.2, U$1.13 (PB3(RESET/PCINT11))
TPICLK: JP1.3, U$1.11 (PB0(CLKI/T0/TPICLK/PCINT8))
TPIDATA: JP1.2, U$1.12 (PB1(OC1A/SDA/MOSI/TPIDATA/PCINT9))

Notes on the sheet:
Vinesauce TMG Badge 2019
Grant Haack
granthaack.com
1.1
4/17/19
Power Management
Charlieplex LED Array
ATTiny20 MCU

Board: 2 copper layers, 99.3 x 99.4 mm, 52 parts (20 on the bottom side), 23 nets.

## Commit log

2019-02-02 final checking phase
2019-02-03 small improvements
2019-02-08 added a wire I forgot about
2019-02-08 sent for manufacturing
2019-03-13 great I made a mistake :(
2019-03-13 small fixes for pcb run 2
2019-03-18 moved to v 1.1
2019-04-12 Create main.c
    literally can't be fucked to install git on my windows box so I'm uploading this manually
2019-04-19 generated some gerbers for the silkscreen cut

Notices in the files:
vine_badge.brd:
CC BY-SA
parts and their libraries:
SparkFun-Switches: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
SparkFun-Aesthetics: Released under the Creative Commons Attribution Share-Alike 4.0 License
SparkFun-Aesthetics: https://creativecommons.org/licenses/by-sa/4.0
